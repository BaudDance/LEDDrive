# Keil uVision project bauddance_1306oled_8h8k64u.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: bauddance_1306oled_8h8k64u +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c main.h config.h oled.c oled.h STC8G_H_I2C.c STC8G_H_I2C.h font.c font.h STC8H.h
